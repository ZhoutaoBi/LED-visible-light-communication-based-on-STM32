# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\App\beep;.\App\delays;.\App\keys;.\App\sensor_AD;.\App\tft;.\App\spi;.\App\sys;.\App\tft2;.\App\oled
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_it.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f10x.c core_cm3.c
  group App
    ./App/beep/: beep.c beep.h
    ./App/delays/: delay.c delay.h
    ./App/sensor_AD/: sensor_AD.c sensor_AD.h
    ./App/tft/: tft.c tft.h
    ./App/spi/: spi.c spi.h
    ./App/tft2/: lcd.c lcd.h lcd_init.c lcd_init.h lcdfont.h misc.c misc.h
    ./App/oled/: oled.c oled.h oledfont.h
software components: CMSIS:CORE 5.2.0, Device:GPIO 1.01.0, Device:StdPeriph Drivers:ADC 3.5.0
